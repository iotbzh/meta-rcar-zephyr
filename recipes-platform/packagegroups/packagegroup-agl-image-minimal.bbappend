
RDEPENDS_${PN} += "\
    zephyr-demo \
    "
